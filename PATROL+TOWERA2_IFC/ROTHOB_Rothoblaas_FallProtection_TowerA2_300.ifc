Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: ea4bd8d1-83ac-496c-824d-680f121bdae3, NumberOfSaves: 31], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_FallProtection_TowerA2_300.ifc
Time: 2025-07-08T17:30:15
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcBuildingElementProxy: Attrezzature speciali : ROTHOB_Rothoblaas_FallProtection_TowerA2 : 150x300x150mm
In: 0_Rothoblaas
Type - PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_StainlessSteelAISI304
Type - Generale - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_FallProtection_TowerA2; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-27 71 21; OmniClassTitle: Fall Arrest Systems; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fall-protection-system/anchor-lines/components/tower-a2; Revision: 001; UniClass2015Code: Pr_40_70_75_75; UniClass2015Title: Safety access anchor devices; UniClass2015Version: Products v1.38; Version: 003
Type - Vincoli - ModelNumberCode: 300; Prospetto di default: 1219.2 mm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_StainlessSteelAISI304
Type - Quote - CylinderDiameter_d1: 48 mm; Height_H: 300 mm; Length_L: 150 mm; Thickness: 8.15 mm; Width_B: 150 mm
Type - Dati identità - Descrizione: Stainless steel support for fall protection systems for timber, steel and concrete roofs; Nome del tipo: 150x300x150mm; Numero OmniClass: 23.27.71.21; Produttore: info@rothoblaas.com
Type - Altro - Categoria: Attrezzature speciali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_70_75_75 - Safety access anchor devices; CodePerformance: Safety system; Color: Silver; Constituents: n/a; Description_x: Stainless steel support for fall protection systems for timber, steel and concrete roofs; DurationUnit: Years; ExpectedLife: n/a; Features: Horizontal lifeline and anchor points; Finish: n/a; Grade: n/a; GTIN: 8054247475321; Manufacturer_x: info@rothoblaas.com; Material: AISI 304 stainless steel grade 1.4301; MinWeight: 2.64 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: TOWERA2300; ModelReference: n/a; Name: Support for fall protection systems; Nome famiglia: ROTHOB_Rothoblaas_FallProtection_TowerA2; NominalHeight: 300 mm; NominalLength: 150 mm; NominalWidth: 150 mm; ReferenceStandard: with PATROL: EN 795:2012 C | CEN/TS 16415:2013 | UNI 11578:2015 C | AS/NZS 1891.2:2001 | AS/NZS 1891.4:2009 | CSA Z259.16 // with H-RAIL: EN 795:2012 D | CEN/TS 16415:2013 | UNI 11578:2015 D | AS/NZS 1891.2:2001 | AS/NZS 1891.4:2009 | BS 8610:2017 D1-D2-D3-D5 // with AOS01: EN 795:2012 A | CEN/TS 16415:2013 | UNI 11578:2015 A | AS/NZS 5532:2013 | AS/NZS 1891.4:2009; ReplacementCost: n/a; Shape: Three-dimensional; Size: 150x300x150 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Support for fall protection systems; Category: Pr_40_70_75_75 - Safety access anchor devices
Type - Pset_ProvisionForVoid - Shape: Three-dimensional
Pset_BuildingElementProxyCommon - Reference: 150x300x150mm; sets with these values: 2
Vincoli - Host: Livello : 0_Rothoblaas; Livello: 0_Rothoblaas; Livello abaco: 0_Rothoblaas; Quota altimetrica da livello: 0 mm
Fasi - Fase di creazione: Stato di Progetto
Quote - Volume: 0.000245935 m3
Altro - Famiglia: ROTHOB_Rothoblaas_FallProtection_TowerA2; Famiglia e tipo: ROTHOB_Rothoblaas_FallProtection_TowerA2: 150x300x150mm; ID tipo: 407203; Tipo: 150x300x150mm
